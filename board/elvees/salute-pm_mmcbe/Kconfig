## board/elvees/salute-pm_mmcbe/Kconfig
```kconfig
if TARGET_SALUTE_PM_MMCBE

config SYS_BOARD
	default "salute-pm_mmcbe"

config SYS_CONFIG_NAME
	default "mcom"

endif
```
